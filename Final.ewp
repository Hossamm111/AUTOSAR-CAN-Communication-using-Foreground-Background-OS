# IAR project Final.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCIncludePath2: C:\ti\TivaWare_C_Series-2.2.0.295
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkAdditionalLibs: C:\ti\TivaWare_C_Series-2.2.0.295\driverlib\ewarm\Exe\driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c startup_ewarm.c
  group Application Layer/Application SWC
    Application Layer/Application SWC/: APP.c APP.h
  group Application Layer/Com Interface Composition SWC/Send Command SWC
    Application Layer/Com Interface Composition SWC/Send Command SWC/: Send_Command.c
  group Application Layer/IO Composition SWC/LED Mode SWC
    Application Layer/IO Composition SWC/LED Mode SWC/: LED_Mode.c
  group BSW/ECUAL/CAN Interface Module
    BSW/ECUAL/CAN Interface module/: Can_Int.c Can_Int.h Can_Int_Cfg.h
  group BSW/ECUAL/I/O Module/Button Module
    BSW/ECUAL/IO Module/Button Module/: Button.c Button.h Button_Cfg.h
  group BSW/ECUAL/I/O Module/LED Module
    BSW/ECUAL/IO Module/LED Module/: Led.c Led.h Led_Cfg.h
  group BSW/ECUAL/Timer Module
    BSW/ECUAL/Timer Module/: Timer.c Timer.h Timer_Cfg.h
  group BSW/MCAL/CAN Driver
    BSW/MCAL/CAN Driver/: Can.c Can.h Can_Cfg.h
  group BSW/MCAL/DIO Driver
    BSW/MCAL/DIO Driver/: Det.h Dio.c Dio.h Dio_Cfg.h Dio_Lcfg.c Dio_MemMap.h
  group BSW/MCAL/GPT Driver
    BSW/MCAL/GPT Driver/: GPT.c GPT.h GPT_Cfg.h
  group BSW/MCAL/Port Driver
    BSW/MCAL/Port Driver/: Port.c Port.h Port_Cfg.h Port_PBcfg.c Port_Regs.h
  group BSW/MCAL/SysTick Timer Driver
    BSW/MCAL/SysTick Timer Driver/: Systick.c Systick.h Systick_Cfg.h
  group BSW/Service Layer/Operating System
    BSW/Service Layer/Operating System/: OS.c OS.h OS_Cfg.h
  group Libraries
    Libraries/: Common_Macros.h Compiler.h Platform_Types.h Std_Types.h tm4c123gh6pm.h tm4c123gh6pm_registers.h
  group RTE
    RTE/: RTE.h
